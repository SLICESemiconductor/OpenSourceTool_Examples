v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -450 -220 350 180 {flags=graph,unlocked
y1=-63.007835

ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0

divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
sim_type=sp
color="12 7 4 10"
node="\\"6dB_pt; -12\\"
\\"side lobe; -32\\"
\\"None; vsquare db20()\\"
\\"Rectangular; vsquare db20()%tb_OTA_sp3.raw sp\\""

hilight_wave=0
y2=8.9713828
x2=20e6
rawfile=tb_OTA_sp2.raw}
