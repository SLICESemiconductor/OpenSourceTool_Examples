v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {N1 bin_out_9 bin_out_8 bin_out_7 bin_out_6 bin_out_5 bin_out_4 bin_out_3 bin_out_2 bin_out_1 bin_out_0 vdda vssa dec2bin_10b dec_code = dec_code}
E {}
C {devices/ipin.sym} -20 -40 0 0 {name=p1 lab=vdda}
C {devices/opin.sym} 40 -40 0 0 {name=p2 lab=bin_out_9}
C {devices/opin.sym} 40 -20 0 0 {name=p3 lab=bin_out_8}
C {devices/opin.sym} 40 0 0 0 {name=p4 lab=bin_out_7}
C {devices/opin.sym} 40 20 0 0 {name=p5 lab=bin_out_6}
C {devices/opin.sym} 40 40 0 0 {name=p6 lab=bin_out_5}
C {devices/opin.sym} 40 60 0 0 {name=p7 lab=bin_out_4}
C {devices/opin.sym} 40 80 0 0 {name=p8 lab=bin_out_3}
C {devices/opin.sym} 40 100 0 0 {name=p9 lab=bin_out_2}
C {devices/opin.sym} 40 120 0 0 {name=p10 lab=bin_out_1}
C {devices/opin.sym} 40 140 0 0 {name=p11 lab=bin_out_0}
C {devices/ipin.sym} -20 -20 0 0 {name=p12 lab=vssa}
C {devices/noconn.sym} 40 -40 0 0 {name=l1}
C {devices/noconn.sym} 40 -20 0 0 {name=l2}
C {devices/noconn.sym} 40 0 0 0 {name=l3}
C {devices/noconn.sym} 40 20 0 0 {name=l4}
C {devices/noconn.sym} 40 40 0 0 {name=l5}
C {devices/noconn.sym} 40 60 0 0 {name=l6}
C {devices/noconn.sym} 40 80 0 0 {name=l7}
C {devices/noconn.sym} 40 100 0 0 {name=l8}
C {devices/noconn.sym} 40 120 0 0 {name=l9}
C {devices/noconn.sym} 40 140 0 0 {name=l10}
C {devices/noconn.sym} -20 -40 2 0 {name=l11}
C {devices/noconn.sym} -20 -20 2 0 {name=l12}
