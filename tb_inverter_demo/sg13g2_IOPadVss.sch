v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} 20 -20 2 0 {name=p3 lab=iovss}
C {iopin.sym} 20 -60 2 0 {name=p4 lab=iovdd}
C {iopin.sym} 20 20 2 0 {name=p5 lab=vdd}
C {iopin.sym} 20 60 2 0 {name=p1 lab=vss}
