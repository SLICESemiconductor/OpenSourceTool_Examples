v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {Agate [in_A in_B] out or_gate_xs}
E {}
C {ipin.sym} 0 -20 0 0 {name=p1 lab=in_A}
C {ipin.sym} 0 20 0 0 {name=p2 lab=in_B}
C {opin.sym} 120 -20 0 0 {name=p3 lab=out}
C {noconn.sym} 120 -20 0 0 {name=l1}
C {noconn.sym} 0 -20 2 0 {name=l2}
C {noconn.sym} 0 20 2 0 {name=l3}
