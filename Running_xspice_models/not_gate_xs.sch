v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {Agate in out not_gate_xs}
E {}
C {ipin.sym} -50 0 0 0 {name=p1 lab=in}
C {opin.sym} 70 0 0 0 {name=p3 lab=out}
C {noconn.sym} 70 0 0 0 {name=l1}
C {noconn.sym} -50 0 2 0 {name=l2}
