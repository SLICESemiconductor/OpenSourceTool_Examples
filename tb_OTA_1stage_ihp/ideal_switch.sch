v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {N1 cn cp n p vdd ideal_sw}
E {}
C {devices/ipin.sym} -20 -40 0 0 {name=p1 lab=vdd}
C {devices/ipin.sym} -20 -20 0 0 {name=p2 lab=cp}
C {devices/ipin.sym} -20 0 0 0 {name=p3 lab=cn}
C {devices/iopin.sym} 40 -20 0 0 {name=p4 lab=p
}
C {devices/iopin.sym} 40 0 0 0 {name=p5 lab=n}
