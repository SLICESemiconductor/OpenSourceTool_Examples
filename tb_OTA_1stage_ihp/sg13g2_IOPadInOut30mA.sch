v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} 0 -40 0 0 {name=p1 lab=p2c}
C {iopin.sym} -140 0 2 0 {name=p3 lab=iovss}
C {iopin.sym} -140 -40 2 0 {name=p4 lab=iovdd}
C {iopin.sym} -140 40 2 0 {name=p5 lab=vdd}
C {iopin.sym} -140 80 2 0 {name=p6 lab=vss}
C {iopin.sym} -140 80 2 0 {name=p7 lab=vss}
C {iopin.sym} -140 120 2 0 {name=p8 lab=cp2}
C {iopin.sym} -140 160 2 0 {name=p9 lab=cp2_en}
C {iopin.sym} -140 200 2 0 {name=p2 lab=pad}
