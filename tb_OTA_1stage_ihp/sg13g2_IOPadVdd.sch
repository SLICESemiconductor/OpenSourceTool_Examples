v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} -40 -40 2 0 {name=p3 lab=iovss}
C {iopin.sym} -40 -80 2 0 {name=p4 lab=iovdd}
C {iopin.sym} -40 0 2 0 {name=p5 lab=vdd}
C {iopin.sym} -40 40 2 0 {name=p1 lab=vss}
