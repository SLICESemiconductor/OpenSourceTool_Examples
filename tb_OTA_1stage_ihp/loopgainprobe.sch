v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {Ii 0 x DC 0 AC 0
Vi x a DC 0 AC 1
Vnodebuffer b x 0}
E {}
C {devices/iopin.sym} 120 0 0 0 {name=p1 lab=b}
C {devices/iopin.sym} 60 0 2 0 {name=p2 lab=a}
